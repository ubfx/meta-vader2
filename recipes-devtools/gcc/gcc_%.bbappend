EXTRA_OECONF_BASE += "--enable-openmp \
    --enable-libgomp \
"